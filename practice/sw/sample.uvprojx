# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F042F6Px/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F042F6Px/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:STM32Cube HAL 1.7.0, CMSIS Driver:CAN 1.0.0, CMSIS Driver:I2C 1.0.0
