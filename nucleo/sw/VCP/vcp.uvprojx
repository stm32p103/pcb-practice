# Keil uVision project vcp.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: vcp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F072RBTx/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F072RBTx/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL 1.7.0, CMSIS Driver:USB Device 1.0.0
